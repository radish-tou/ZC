# Keil uVision project FZTY2026010.uvprojx, settings and files
target FZTY2026010 (6140000::V6.14::ARMCLANG)
  device: APM32F407ZG Geehy
  pack: Geehy.APM32F4xx_DFP.1.0.11
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FZTY2026010 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Ch394q;../Public;../Bsp;../SPI_BitBang;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c wdg.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_wwdg.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Bsp
    ../Bsp/: Bsp.c CH394Q_Dev.c RS232_422_485.c CAN_Comm.c Di_Acq.c Do_Ctrl.c Ai_Acq.c
  group App
    ../APP/: App.c host.c sensor.c motor.c para.c power.c
  group Ch394q
    ../Ch394q/: CH394Q.c CH394Q_DHCP.c CH394Q_DNS.c CH394Q_NET.c CH394Q_SPI.c
  group Public
    ../Public/: delay.c MySys.c w25q128.c
  group SPI_Bitbang
    ../SPI_BitBang/: Spi_BitBang.c
software components: CMSIS:CORE 5.6.0
